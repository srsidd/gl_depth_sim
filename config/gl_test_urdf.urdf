Commit message: Removed extra files

File: config/gl_test_urdf.urdf (robot description, URDF)
Before this commit: robot gl_depth_sim, 1 links, 0 joints
Links:
- link world: geometry visual mesh filename=package://gl_depth_sim/config/test.stl
